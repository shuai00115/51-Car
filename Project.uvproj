# Keil uVision project Project.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Motor.c Motor.h Timer1.c Timer1.h Timer0.c Timer0.h LightSensor.c LightSensor.h
